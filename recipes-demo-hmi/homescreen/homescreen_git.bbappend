FILESEXTRAPATHS_prepend := "${THISDIR}/file:"

SRC_URI_append = " file://0001-changing-window-size-adjustably.patch"
